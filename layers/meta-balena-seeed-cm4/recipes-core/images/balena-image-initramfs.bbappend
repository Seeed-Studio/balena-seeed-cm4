IMAGE_ROOTFS_MAXSIZE:raspberrypi4-64 = "51200"