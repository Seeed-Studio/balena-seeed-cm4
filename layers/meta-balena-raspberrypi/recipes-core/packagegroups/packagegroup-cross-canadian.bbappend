# PN embeds ${MACHINE}; allow upper-case machine names (e.g. seeed-reterminal-DM)
ERROR_QA:remove = "uppercase-pn"
